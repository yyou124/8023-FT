# IAR project STM8-8023-FT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: FWlib\inc; User; User\Head; User\I2C_SPEED; User\delay
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8-8023-FT.hex
  ILINK.IlinkOutputFile: STM8-8023-FT.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    FWlib/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart2.c
  group User
    User/delay/: delay.c
    User/: i2c_driver_soft.c main.c process.c stm8s_it.c timer_driver.c uart_driver.c
  group User/IIC-Speed
    User/I2C_SPEED/: i2c_speed200.c i2c_speed300.c i2c_speed400.c i2c_speed500.c i2c_speed600.c
