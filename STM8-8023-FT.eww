<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8-8023-FT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


